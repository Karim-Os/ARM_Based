# Keil uVision project Gpio_Tests.uvprojx, settings and files
target App_Gpio_Test (6180000::V6.18::ARMCLANG)
  device: TM4C123GE6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Gpio_Tests (library)
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: GPIO_APB
  c include: ..\Common;..\Gpio\Includes;..\Mcal\Includes;..\Mcu\Includes;..\Gpt\Includes;..\Mcal\Includes
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group App
    ./: Gpio_App.c
  group Source
    ../Gpio/: Gpio.c
    ../Mcu/: Mcu.c
    ../Mcal/: IntCtrl.c
    ../Gpt/: Gpt.c
    ../Adc/: Adc.c
    ../Wdt/: Wdt.c
  group Cfgs
    ../Adc/: Adc_Lcfg.c
    ../Gpio/: Gpio_Lcfg.c
    ../Gpt/: Gpt_Lcfg.c
    ../Mcal/: IntCtrl_Lcfg.c
    ../Mcu/: Mcu_Lcfg.c
    ../Wdt/: Wdt_Lcfg.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
