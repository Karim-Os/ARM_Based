# Keil uVision project ARM.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ARM +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c include: ..\ARM\MCAL\Common;..\ARM\MCAL\DIO\inc;..\ARM\MCAL\GPT\inc;..\ARM\MCAL\IntCtrl\inc;..\ARM\MCAL\MCU\inc;..\ARM\MCAL\PORT\inc;..\ARM\HAL\LED\inc;..\ARM\APP\Blink;..\ARM\MCAL\SYSTICK\inc;..\ARM;..\..\..\ARM_Based-master\Wdt\Includes;..\Keil
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x40000000 size 0x1ffffff
  group Source Group 1
    ../ARM/APP/: main.c
    ./: wdt_driver.c wdt.h common.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
